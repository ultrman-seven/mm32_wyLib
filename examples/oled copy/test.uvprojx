# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.5
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EIGEN_NO_IO
  c misc: --cpp11
  c include: ..\..\MM32SPIN2xx_p_LIB\Include;..\..\MM32SPIN2xx_p_LIB\HAL_lib\inc;..\..\CMSIS\KEIL_CORE;.\src;..\..\WyCppHal\inc;..\..\WyLib\OLED;..\..\Eigen;..\..\Eigen\src;..\..\Eigen\src\Cholesky;..\..\Eigen\src\CholmodSupport;..\..\Eigen\src\Core;..\..\Eigen\src\Core\arch;..\..\Eigen\src\Core\arch\AltiVec;..\..\Eigen\src\Core\arch\AVX;..\..\Eigen\src\Core\arch\AVX512;..\..\Eigen\src\Core\arch\CUDA;..\..\Eigen\src\Core\arch\Default;..\..\Eigen\src\Core\arch\GPU;..\..\Eigen\src\Core\arch\HIP;..\..\Eigen\src\Core\arch\HIP\hcc;..\..\Eigen\src\Core\arch\MSA;..\..\Eigen\src\Core\arch\NEON;..\..\Eigen\src\Core\arch\SSE;..\..\Eigen\src\Core\arch\SVE;..\..\Eigen\src\Core\arch\SYCL;..\..\Eigen\src\Core\arch\ZVector;..\..\Eigen\src\Core\functors;..\..\Eigen\src\Core\products;..\..\Eigen\src\Core\util;..\..\Eigen\src\Eigenvalues;..\..\Eigen\src\Geometry;..\..\Eigen\src\Geometry\arch;..\..\Eigen\src\Householder;..\..\Eigen\src\IterativeLinearSolvers;..\..\Eigen\src\Jacobi;..\..\Eigen\src\KLUSupport;..\..\Eigen\src\LU;..\..\Eigen\src\LU\arch;..\..\Eigen\src\MetisSupport;..\..\Eigen\src\misc;..\..\Eigen\src\OrderingMethods;..\..\Eigen\src\PardisoSupport;..\..\Eigen\src\PaStiXSupport;..\..\Eigen\src\plugins;..\..\Eigen\src\QR;..\..\Eigen\src\SparseCholesky;..\..\Eigen\src\SparseCore;..\..\Eigen\src\SparseLU;..\..\Eigen\src\SparseQR;..\..\Eigen\src\SPQRSupport;..\..\Eigen\src\StlSupport;..\..\Eigen\src\SuperLUSupport;..\..\Eigen\src\SVD;..\..\Eigen\src\UmfPackSupport;..\..\WyLib\FLASH;..\..\WyLib\MOTOR
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group HAL
    ../../MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.cpp HAL_comp.cpp HAL_crc.cpp HAL_div.cpp HAL_dma.cpp HAL_exti.cpp HAL_flash.cpp HAL_gpio.cpp HAL_i2c.cpp HAL_iwdg.cpp HAL_misc.cpp HAL_op.cpp HAL_pwr.cpp HAL_rcc.cpp HAL_spi.cpp HAL_syscfg.cpp HAL_tim.cpp HAL_uart.cpp HAL_wwdg.cpp
  group STARTUP
    ../../MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
    ../../MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.cpp
  group USER
    ../../WyLib/OLED/: oled.cpp font.cpp a_gif.cpp z_gif.cpp
    ./src/: main.cpp hander.c
    ../../WyCppHal/src/: generalOutput.cpp
    ../../WyLib/FLASH/: w25q64.cpp
  group WY
    ../../WyCppHal/src/: common.cpp wy_iic.cpp wy_spi.cpp wy_uart.cpp wy_tim.cpp wy_8080.cpp wy_hardOperation.cpp wy_key.cpp wy_gpio.cpp
    ../../WyLib/MOTOR/: stepMotor.cpp
